# Keil uVision project final.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: STM32F401VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: final +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Drivers\CMSIS\Device\ST\STM32F4xx\Include;.\Drivers\CMSIS\Include;.\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: main.c system_clock_config.c delay.c dht11.c dht11.h delay.h
    ./Core/Src/: stm32f4xx_hal_msp.c stm32f4xx_it.c
software components: CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0, CMSIS Driver:USART 2.16, Device:STM32Cube Framework:Classic 1.8.1, Device:STM32Cube HAL:Common 1.8.1, Device:STM32Cube HAL:Cortex 1.8.1, Device:STM32Cube HAL:DMA 1.8.1, Device:STM32Cube HAL:GPIO 1.8.1, Device:STM32Cube HAL:PWR 1.8.1, Device:STM32Cube HAL:RCC 1.8.1, Device:STM32Cube HAL:USART 1.8.1, Device:Startup 2.6.3
